# Keil uVision project JBUhover.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: JBUhover +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: systick.c JBUhover.c gd32f1x0_it.c gd32f1x0_it.h systick.h gd32f1x0.h define.h initialization.c initialization.h operations.c operations.h
software components: CMSIS:CORE 5.5.0, Board Support:LED 3.2.0, Device:GD32F1x0_EVAL 3.2.0, Device:GD32F1x0_StdPeripherals:ADC 3.2.0, Device:GD32F1x0_StdPeripherals:EXTI 3.2.0, Device:GD32F1x0_StdPeripherals:GPIO 3.2.0, Device:GD32F1x0_StdPeripherals:MISC 3.2.0, Device:GD32F1x0_StdPeripherals:RCU 3.2.0, Device:GD32F1x0_StdPeripherals:SYSCFG 3.2.0, Device:GD32F1x0_StdPeripherals:USART 3.2.0, Device:GD32F1x0_libopt 3.2.0, Device:Startup 3.2.0
